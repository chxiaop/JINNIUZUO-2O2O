# Keil uVision project rm_main.uvprojx, settings and files
target rm_main (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: rm_main +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,__FPU_PRESENT=1U,__FPU_USED =1U,ARM_MATH_CM4,__CC_ARM
  c include: ../Inc;          ../Drivers/STM32F4xx_HAL_Driver/Inc;          ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;          ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;          ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;          ..\app;          ..\bsp;          ..\mathlib;          ..\SystemView;          ..\SystemView\Config;          ..\SystemView\FreeRTOSV9;          ..\SystemView\FreeRTOSV9\Config;          ..\SystemView\FreeRTOSV9\Patch;          ..\SystemView\SEGGER;          ..\bsp;          ..\control;   ../Middlewares/Third_Party/FreeRTOS/Source/include;   ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;   ../Drivers/CMSIS/Include
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c can.c dma.c freertos.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_TIM.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f4xx.c
  group Application/UserBsp
    ../bsp/: bsp_can.c bsp_uart.c bsp_JY901.c bsp_powerlimit.c bsp_supercap.c bsp_macroenergy.c bsp_FricMotor.c bsp_CoverServo.c bsp_TriggerMotor.c bsp_imu.c
  group Application/AppCtrl
    ../app/: chassis_task.c modeswitch_task.c supercap_task.c gimbal_task.c shoot_task .c status_task.c judge_send_task.c judge_unpack_task.c flagCheck_task.c
  group Application/Comm
    ../app/: comm_task.c visionfire_task.c
  group Application/MathLib
    ../mathlib/: pid.c remote_msg.c data_processing.c DataScope_DP.C define_printf.c math_calcu.c data_fifo.c judgement_info.c protocol.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
software components: CMSIS:CORE 4.3.0
